# Keil uVision project KK.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KK
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\hardware\angleEncoder;.\hardware\exit;.\hardware\key;.\hardware\PWM;.\hardware\spi;.\hardware\stepMoto;.\hardware\sys;.\hardware\timer;.\hardware\ultrasonic;.\hardware\usart;.\user;.\hardware\mpu6050;.\hardware\mpu6050\eMPL;.\hardware\lcd;.\hardware\openMV;.\hardware\moto
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c display.c Control.c
  group hardware
    ./hardware/sys/: delay.c sys.c
    ./hardware/usart/: usart.c usart2.c
    ./hardware/timer/: timer.c
    ./hardware/PWM/: pwmOutput.c
    ./hardware/key/: key.c
    ./hardware/mpu6050/: angle.c STM32_I2C.c
    ./hardware/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./hardware/lcd/: fonts.c bsp_ili9341_lcd.c
    ./hardware/moto/: moto.c
    ./hardware/openMV/: openMV.c
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
